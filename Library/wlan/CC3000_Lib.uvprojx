# Keil uVision project CC3000_Lib.uvprojx, settings and files
target CC3000_Lib (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CC3000_Lib (library)
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,
  c include: ..\..\App;..\STM32_Lib\inc;..\CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CC000_Lib
    ./: netapp.c nvmem.c security.c socket.c wlan.c cc3000_common.c evnt_handler.c hci.c cc3000spi.c
