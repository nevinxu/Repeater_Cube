# Keil uVision project Repeater_Project.uvprojx, settings and files
target Repeater_Project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wifi_project +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,
  c include: ..\App;..\Bsp;..\Library\CM3;..\Library\STM32_Lib\inc;..\\OS-uCOSII\core;..\\OS-uCOSII\port;..;../Library;../driver;..\driver\cc1101;..\wlan;..\driver\Uart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F10x_CM3
    ../Library/CM3/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../Library/CM3/startup/: startup_stm32f10x_md.s
  group APP
    ../App/: app.c CC3000_Task.c CC3000_Task.h wifi_application.c wifi_application.h DataProcess.c Dataprocess.h LcdDisplay.c stm32f10x_it.c includes.h
  group BSP
    ../Bsp/: bsp.c bsp.h
  group driver
    ../driver/w25x40/: spi_flash.c
    ../driver/LCD/: UC1701X.c
    ../driver/cc1101/: cc1101.c
    ../driver/Uart/: uart.c uart.h
  group ReadMe
    ../: readme.txt
  group LIB
    ../OS-uCOSII/: COSII_Lib.lib
    ../Library/STM32_Lib/: STM32_Lib.lib
    ../Library/wlan/: CC3000_Lib.lib
  group wlan
    ../wlan/: cc3000_common.c cc3000spi.c evnt_handler.c hci.c netapp.c nvmem.c security.c socket.c wlan.c
  group STM32_Lib
    ../Library/STM32_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
